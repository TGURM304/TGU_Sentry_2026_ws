Commit message: nothing

File: src/sentry_description/urdf/sentry_description.urdf (robot description, URDF)
Before this commit: robot sentry_lidar_minimal, 3 links, 2 joints
Joints:
- joint yaw_to_lidar: origin xyz=0.11 0 0.30 rpy=0 0 0 -> xyz=0.11 0 0.30 rpy=0 -0.785398 0
